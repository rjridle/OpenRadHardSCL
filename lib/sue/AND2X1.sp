* FILE: AND2X1.sp

* SPICE netlist for "AND2X1" generated by MMI_SUE5.6.37 on Mon Jan 24
*+ 10:15:58 CST 2022.

.SUBCKT AND2X1 A B Y
M_1 Y net_1 vdd vdd p W='3*1u' L=0.15u ad='areap(3,sdd)'
+ as='areap(3,sdd)' pd='perip(3,sdd)' ps='perip(3,sdd)'
M_2 net_1 A vdd vdd p W='3*1u' L=0.15u ad='areap(3,sdd)'
+ as='areap(3,sdd)' pd='perip(3,sdd)' ps='perip(3,sdd)'
M_3 net_1 B vdd vdd p W='3*1u' L=0.15u ad='areap(3,sdd)'
+ as='areap(3,sdd)' pd='perip(3,sdd)' ps='perip(3,sdd)'
M_4 Y net_1 gnd gnd n W='1*1u' L=0.15u ad='arean(1,sdd)'
+ as='arean(1,sdd)' pd='perin(1,sdd)' ps='perin(1,sdd)'
M_5 net_1 A net_2 gnd n W='1*1u' L=0.15u ad='arean(1,sdd)'
+ as='arean(1,sdd)' pd='perin(1,sdd)' ps='perin(1,sdd)'
M_6 net_2 B gnd gnd n W='1*1u' L=0.15u ad='arean(1,sdd)'
+ as='arean(1,sdd)' pd='perin(1,sdd)' ps='perin(1,sdd)'
.ENDS	$ AND2X1

.GLOBAL gnd vdd
